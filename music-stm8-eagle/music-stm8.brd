# Repository JackyYuenDacai/stm8-music

File README.md:

# stm8-music
mp3 player using stm8sxxx (LQFP32) and vs1001k 

basic functions completed.

call playMusic(char*) to play mp3 music

noted only support fluent play with bit rate around 192kbits/s.(stm8s have maximum of 24Mhz clock)

Some sources and headers are not needed, but can replace some current module , perhaps can improve io speed of fat32 fs .

## EAGLE design music-stm8-eagle/music-stm8.brd

Parts:
C1, C2, C13, C14: 22pF; C0402
C3: 100nF; C0402
C4, C5, C8, C9: 100nF; C0603
C6, C7: 100uF; E5-10,5
C10, C11: 220uF; B45181A
C15: 1uF; C0402
C16: 104; C2.5-2
IC1: STM8S105K6T; LQFP32-7X7
IC2: REG1117; SOT223
J1: CON-SD-MMC-1; 14-5638-009-511-862
LCD0: I2C; 1X04
LED1: TLLG4400; LED3MM
LED2: TLLR4400; LED3MM
LED3: TLLY4400; LED3MM
Q1: 24.576mHz; HC49U-V
Q2: 8mHz; HC49U-V
R1: 10k; R0603
R2: 10k; 0204/7
R3: 1M; 0207/10
R5: 1k/470; 0207/7
R6, R7: R-EU_0207/7; 0207/7
S1: 9450-2
S2, S3: DTS-6
SWIM-DEBUG: SWIM; MA04-1
U$3: VS1001-SOIC-28; SO-28L
X1: SJ-3524-SMT
X2: MINI-USB-32005-301; 32005-301

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C8.1, C9.2, C10.-, C11.-, C13.1, C14.1, C15.1, C16.1, IC1.4 (VSS), IC1.10 (VSSA), IC2.1 (GND), J1.3, J1.6, J1.GND (POL/GND), LCD0.1, S1.1 (S), S2.1, S3.1, SWIM-DEBUG.4, U$3.6 (DGND), U$3.10 (DGND), U$3.18 (AGND), U$3.21 (AGND), U$3.25 (AGND), U$3.27 (DGND), X1.1 (EARTH)
unnamed: C3.1, U$3.22 (RCAP)
unnamed: C1.1, Q1.2, R3.2, U$3.7 (XTAL0)
unnamed: IC1.23 (PC6/SPI_MOSI), U$3.14 (SO)
unnamed: R1.2, U$3.15 (TEST0)
unnamed: IC1.24 (PC7/SPI_MISO), U$3.13 (SI)
unnamed: C2.1, Q1.1, R3.1, U$3.8 (XTAL1)
unnamed: IC1.22 (PC5/SPI_SCK), U$3.12 (SCLK)
unnamed: IC1.21 (PC4/TIM1_CH4), U$3.11 (XCS)
unnamed: IC1.20 (PC3/TIM1_CH3), U$3.26 (XRESET)
unnamed: IC1.19 (PC2/TIM1_CH2), U$3.1 (DREQ)
unnamed: IC1.18 (PC1/TIM1_CH1/UART2_CK), U$3.3 (SDATA)
unnamed: IC1.17 (PE5/SPI_NSS), U$3.2 (DCLK)
unnamed: IC1.16 (PB0/AIN0[TIM1_CH1N]), U$3.4 (BSYNC)
unnamed: S1.2, X2.5
unnamed: IC1.32 (PD7/TLI[TIM1_CH4]), J1.1
unnamed: C8.2, C10.+, IC2.3 (VIN), X2.1
unnamed: C16.2, IC1.1 (NRST), R2.1, SWIM-DEBUG.3
unnamed: C13.2, IC1.2 (PA1/OSC), Q2.2
unnamed: C14.2, IC1.3 (PA2/OSCOUT), Q2.1
unnamed: IC1.31 (PD6/UART2_RX), J1.2
unnamed: IC1.26 (PD1/SWIM), SWIM-DEBUG.2
unnamed: IC1.27 (PD2/TIM3_CH1[TIM2_CH3]), J1.5
unnamed: IC1.12 (PB4/AIN4[I2C_SCL]), LCD0.3
unnamed: IC1.11 (PB5/AIN5[I2C_SDA]), LCD0.4
unnamed: IC1.30 (PD5/UART2_TX), J1.7
unnamed: IC1.29 (PD4/TIM2_CH1[BEEP]), J1.8
unnamed: IC1.28 (PD3/TIM2_CH2[ADC_ETR]), J1.9
unnamed: IC1.14 (PB2/AIN2[TIM1_CH3N]), LED2.K (C)
unnamed: IC1.13 (PB3/AIN3[TIM1_ETR]), LED3.K (C)
unnamed: IC1.15 (PB1/AIN1[TIM1_CH2N]), LED1.K (C)
unnamed: LED1.A, R5.2
unnamed: LED2.A, R6.2
unnamed: LED3.A, R7.2
unnamed: C15.2, IC1.5 (VCAP)
unnamed: IC1.25 (PD0/TIM3_CH2[TIM1_BKIN][CLK_CCO]), S2.3
unnamed: IC1.8 (PF4/AIN12), S3.3
unnamed: C6.+, U$3.24 (LEFT)
unnamed: C7.+, U$3.20 (RIGHT)
unnamed: C6.-, X1.2 (TIP)
unnamed: C7.-, X1.3 (RING)
VDD: C4.1, C5.1, C9.1, C11.+, IC1.6 (VDD), IC1.7 (VDDIO_1), IC1.9 (VDDA), IC2.2 (VOUT), J1.4, LCD0.2, R1.1, R2.2, R5.1, R6.1, R7.1, SWIM-DEBUG.1, U$3.5 (DVDD), U$3.9 (DVDD), U$3.19 (AVDD), U$3.23 (AVDD), U$3.28 (DVDD)

Board: 2 copper layers, 76.2 x 48.9 mm, 37 parts (8 on the bottom side), 42 nets.

## Commit log

2017-12-27 mistakes regarding pcb
2018-01-02 Delete music-stm8.png
    you can render your own pcb board.
2018-01-13 Update oledfont.h
    delete unused const value

Notices in the files:
parts and their libraries:
m-pad-2.1: License : GNU General Public License version 2 (see bottom)
